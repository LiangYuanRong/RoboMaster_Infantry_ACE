# Keil uVision project INFANTRY_2020_407.uvprojx, settings and files
target Infantry2020 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: INFANTRY_2020_407
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\init;..\SYSTEM\sys;..\SYSTEM\usart;..\USER\DEFINE\MODE_DEF;..\USER\DEFINE\PID_DEF;..\USER\DEFINE\SPEED_DEF;..\USER\FreeRTOS\include;..\USER\FreeRTOS\include;..\USER\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER\HARDWARE\BEEP;..\USER\HARDWARE\BMI160;..\USER\HARDWARE\CAN1;..\USER\HARDWARE\CAN2;..\USER\HARDWARE\IWDG;..\USER\HARDWARE\LED;..\USER\HARDWARE\OLED;..\USER\HARDWARE\PHOTOELECTRIC;..\USER\HARDWARE\PWM;..\USER\HARDWARE\REMOTE;..\USER\HARDWARE\TIM;..\USER\INTERFACE\AUTOMATIC_STRIKE;..\USER\INTERFACE\CAN_ISR;..\USER\INTERFACE\DOUBLE_GIMBAL;..\USER\INTERFACE\MATHS\KALMAN_FILTER;..\USER\INTERFACE\MATHS\MATH;..\USER\INTERFACE\PID;..\USER\INTERFACE\RMMOTOR;..\USER\TASK\CHASSIS_TASK;..\USER\TASK\FIRE_TASK;..\USER\TASK\GIMBAL_TASK;..\USER\TASK\GYRO_TASK;..\USER\TASK\REMOTE_TASK;..\USER\TASK\SAFE_CHECK_TASK;..\USER\TASK\START_TASK;..\USER;..\DSP_LIB\Include;..\USER\HARDWARE\KEY;..\USER\HARDWARE\SPI;..\USER\Referee;..\USER\INTERFACE\CAPACITOR;..\USER\INTERFACE\POWER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../START_UP/: startup_stm32f40_41xxx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSPLIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group FREERTOS
    ../USER/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../USER/FreeRTOS/portable/MemMang/: heap_4.c
    ../USER/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/init/: system.c
    ../SYSTEM/sys/: sys.c
  group MAIN
    ../USER/: main.c
  group HARDWARE
    ../SYSTEM/usart/: usart.c
    ../USER/HARDWARE/LED/: led.c
    ../USER/HARDWARE/OLED/: oled.c
    ../USER/HARDWARE/BEEP/: beep.c
    ../USER/HARDWARE/CAN1/: can1.c
    ../USER/HARDWARE/CAN2/: can2.c
    ../USER/HARDWARE/IWDG/: iwdg.c
    ../USER/HARDWARE/MPU6050/I2C/: I2Cdev.c
    ../USER/HARDWARE/PHOTOELECTRIC/: photoelectric.c
    ../USER/HARDWARE/PWM/: pwm.c
    ../USER/HARDWARE/TIM/: time.c
    ../USER/HARDWARE/SPI/: spi.c
    ../USER/HARDWARE/KEY/: key.c
  group DEFINE
    ../USER/DEFINE/MODE_DEF/: Mode_Def.h
    ../USER/DEFINE/PID_DEF/: PID_Def.h
    ../USER/DEFINE/SPEED_DEF/: Speed_Def.h
  group REFEREE
    ../USER/Referee/: CRC.c RefereeDeal.c UserReferee.c
  group INTERFACE
    ../USER/HARDWARE/REMOTE/: remote.c
    ../USER/HARDWARE/BMI160/: BMI160.c
    ../USER/INTERFACE/AUTOMATIC_STRIKE/: automatic_strike.c
    ../USER/INTERFACE/CAN_ISR/: CanISR.c
    ../USER/INTERFACE/DOUBLE_GIMBAL/: Double_Gimbal.c
    ../USER/INTERFACE/MATHS/MATH/: maths.c
    ../USER/INTERFACE/MATHS/KALMAN_FILTER/: kalman_filter.c
    ../USER/INTERFACE/PID/: pid.c
    ../USER/INTERFACE/RMMOTOR/: rmmotor.c
    ../USER/INTERFACE/CAPACITOR/: Capacitor_control.c
  group TASK
    ../USER/TASK/START_TASK/: StartTask.c
    ../USER/TASK/REMOTE_TASK/: Remote_Task.c
    ../USER/TASK/GIMBAL_TASK/: Gimbal_Task.c
    ../USER/TASK/CHASSIS_TASK/: Chassis_Task.c
    ../USER/TASK/FIRE_TASK/: Fire_Task.c
    ../USER/TASK/GYRO_TASK/: Gyro_Task.c
    ../USER/TASK/SAFE_CHECK_TASK/: Safecheck_Task.c
